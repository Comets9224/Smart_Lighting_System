# Keil uVision project Smart_Lighting_System.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能照明节能系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c lcd12864.c uart.h lcd12864.h timer.h timer.c key.c key.h main.h func.c func.h bh1750.c bh1750.h i2c.c i2c.h pwm.c pwm.h
